# Keil uVision project cube_application.uvprojx, settings and files
target cube_application (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cube_application
  AfterMake: fromelf --bin build\app\cube_application.axf --output build\app\cube_application.bin
  AfterMake: python ./tools/sign.py build/app/cube_application.bin build/cube.dfu tools/key.h
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./sdk/platform/driver/gpio;./sdk/platform/arch/;./sdk/platform/arch/compiler/rvds/;./sdk/platform/arch/ll/rvds/;./sdk/platform/include/;./sdk/platform/driver/reg/;./src/config;./sdk/platform/core_modules/rwip/api;./sdk/common_project_files/
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app\application.sct
  group src
    ./app/: boot.s accel.c animation.c lights.c main.c uart.c adc.c
  group sdk
    ./sdk/platform/driver/gpio/: gpio.c
software components: CMSIS:CORE 5.0.1
