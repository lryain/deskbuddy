# Keil uVision project sysboot.uvprojx, settings and files
target syscon (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sysboot
  BeforeMake: python ./tools/export.py build/publickeys.h
  AfterMake: fromelf --bin build\sysboot\sysboot.axf --output build\sysboot.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030X8,BOOTLOADER,WHISKEY
  c misc: --gnu
  c include: boot;common;schema;crypto;build
  asm define: WHISKEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1ffc
  group boot
    ./boot/: main.cpp system_stm32f0xx.c comms.cpp startup_stm32f030x8.s analog.cpp
    ./crypto/: bignum.cpp rsa_pss.cpp sha256.cpp
  group common
    ./common/: flash.cpp
    ./boot/: power.cpp
software components: CMSIS:CORE 5.0.1
