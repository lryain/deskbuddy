# Keil uVision project vicfix.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vicfix +hex
  BeforeMake: cmd /c del build\binaries.o
  BeforeMake: cmd /c del fixture.safe
  AfterMake: fromelf --bin build\vicfix.axf --output build\vicfix.bin
  AfterMake: crypto\Release_FIXTURE\makesafe_fixture -prod fixture.safe build\vicfix.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FIXTURE,STM32F2XX,USE_STDPERIPH_DRIVER,DEBUG
  c misc: --exceptions --exceptions_unwind
  c include: .;app;common;hal;inc;lib;stm32f2xx;tests;xxx
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\vicfix.sct
  link misc: --datacompressor off
  group app
    ./app/: app.cpp binaries.s binariesc.c fixture.cpp cmd.cpp robotcom.cpp
  group tests
    ./tests/: TestBody.cpp TestCommon.cpp TestHead.cpp TestBackpack.cpp TestCube.cpp TestRobot.cpp TestMotor.cpp TestDebugStub.cpp TestDebugHeadprogram.cpp
  group lib
    ./lib/: crc16.c crc32.c spine_crc.c nvReset.c swd.cpp swd_stm32.cpp swd_da1458x.cpp
  group hal
    ./hal/: board.cpp bpled.cpp system_stm32f2xx.c startup_stm32f2xx.s stm32fxxx_it.c flash.c console.c meter.cpp motorled.c random.c dut_uart.cpp bdaddr.c flexflow.cpp
    ./common/: contacts.cpp timer.cpp
  group stm32f2xx
    ./stm32f2xx/: misc.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_tim.c stm32f2xx_pwr.c stm32f2xx_usart.c stm32f2xx_spi.c stm32f2xx_dma.c stm32f2xx_adc.c
  group crypto
    ./crypto/: opensafe.c
software components: CMSIS:CORE 5.6.0
